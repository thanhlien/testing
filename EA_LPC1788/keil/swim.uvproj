# Keil uVision project swim.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: swim +hex
  c flags: Optim=1
  c define: PORTRAIT=1
  c include: ..\Common\inc;..\..\..\swim;..\..\swim;..\
  asm define: NO_CRP
  asm include: ..\Common\inc;..\..\..\..\..\..\..\lpc\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ../common/src/: startup_LPC177x_8x.s
  group System Code
    ../common/src/: system_LPC177x_8x.c
  group Source
    ./app/: ex_sdram.c lcd_colorbars.c lcd_driver.c lcd_test.c SMA_16bpp_example.c timer.c ssp.c truly_g240320ltsw.c clkpwr.c lcd_params.c
  group swim
    ../../swim/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_rom8x16.c lpc_rom8x8.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
  group Documentation
    ./doc/: abstract.txt
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: swim +hex
  c flags: Optim=1
  c define: PORTRAIT=1
  c include: ..\Common\inc;..\..\..\..\swim;..\..\..\swim;..\..\swim
  asm define: NO_CRP
  asm include: ..\Common\inc;..\..\..\..\..\..\..\lpc\include
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000

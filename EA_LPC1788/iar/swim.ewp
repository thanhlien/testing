# IAR project swim.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1768_SK; FLASH_LPC1768; PORTRAIT
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe161
  ICCARM.CCIncludePath2: ..\common\inc; ..\..\swim; app
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: swim.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    doc/: abstract.txt
  group CMSIS
    ../common/src/: core_cm3.c system_LPC177x_8x.c
  group Source
    app/: clkpwr.c ex_sdram.c lcd_colorbars.c lcd_driver.c lcd_params.c lcd_test.c SMA_16bpp_example.c ssp.c timer.c truly_g240320ltsw.c
  group Startup Code
    ./: cstartup_M.s
  group swim
    ../../swim/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_rom8x16.c lpc_rom8x8.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
